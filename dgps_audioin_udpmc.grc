options:
  parameters:
    generate_options: qt_gui
    id: dgps_msk_udp
    output_language: python
  states: {}

blocks:
- name: decim
  id: variable
  parameters:
    value: '40'
  states: {}
- name: dgpsbaudrate
  id: variable_qtgui_chooser
  parameters:
    label: dgpsbaudrate
    label0: '100'
    label1: '200'
    num_opts: '2'
    option1: '200'
    type: int
    value: '100'
    widget: radio_buttons
  states: {}
- name: finetune
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-300'
    step: '1'
    stop: '300'
    value: '0'
  states: {state: disabled}
- name: freq_offset
  id: variable
  parameters:
    value: '500'
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: dgpsbaudrate/2
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: transition_bw
  id: variable
  parameters:
    value: '300'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: float
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: (samp_rate/decim)/(2*math.pi*fsk_deviation_hz/8.0)
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: int((samp_rate/decim)/dgpsbaudrate)
    max_iter: '4000'
    scale: 1/((samp_rate/decim)/dgpsbaudrate)
    type: float
  states: {}
- name: blocks_repeat_0_0
  id: blocks_repeat
  parameters:
    interp: int((samp_rate/decim)/dgpsbaudrate)
    type: byte
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '30'
    type: byte
  states: {}
- name: blocks_udp_sink_0_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 225.0.0.1
    port: '10000'
    psize: '1472'
    type: byte
    vlen: '30'
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '1024'
    long_form: 'True'
    type: ff
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: int((samp_rate/decim)/dgpsbaudrate)
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_offset
    decim: decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, samp_rate/(2*decim), transition_bw)
    type: fcc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: dgpsbaudrate*3/4
    decim: '1'
    gain: '1'
    samp_rate: samp_rate/decim
    type: fir_filter_ccf
    width: dgpsbaudrate/4
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    label1: ''
    label2: ''
    nconnections: '2'
    size: '4096'
    srate: samp_rate/decim
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/decim
    fc: '0'
    fftsize: '256'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_moving_average_xx_0, '0']
- [analog_agc_xx_0, '0', qtgui_time_sink_x_0, '1']
- [analog_quadrature_demod_cf_0, '0', dc_blocker_xx_0, '0']
- [audio_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_moving_average_xx_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [blocks_repeat_0_0, '0', blocks_char_to_float_0_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_udp_sink_0_0, '0']
- [dc_blocker_xx_0, '0', analog_agc_xx_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_repeat_0_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_stream_to_vector_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
